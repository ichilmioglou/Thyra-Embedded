## boards/Thyra/nrf52840dk_custom/Kconfig.defconfig
```kconfig
if BOARD_NRF52840DK_CUSTOM

config BT_CTLR
	default BT

endif # BOARD_NRF52840DK_CUSTOM
```
